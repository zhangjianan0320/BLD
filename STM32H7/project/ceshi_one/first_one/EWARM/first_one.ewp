# IAR project first_one.ewp, settings and files
configuration first_one (ARM, debug)
  General.OGChipSelectEditMenu: STM32H753II ST STM32H753II
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 7
  ICCARM.CCDefines: MBEDTLS_CONFIG_FILE="mbedtls_config.h"; USE_HAL_DRIVER; STM32H753xx
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Middlewares/Third_Party/mbedTLS/include; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Utilities/JPEG; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/Third_Party/LibJPEG/include; ../Drivers/BSP/Components/lan8742; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/ST/STM32_Audio/Addons/PDM/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Inc; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/system/arch; ../Middlewares/Third_Party/mbedTLS/include/mbedtls; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: first_one.hex
  ILINK.IlinkOutputFile: first_one.out
  ILINK.IlinkIcfFile: stm32h753xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h753xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c crc.c cryp.c dac.c dma.c dma2d.c bsp_driver_sdram.c sdram_diskio.c fatfs.c bsp_driver_sram.c sram_diskio.c bsp_driver_sd.c sd_diskio.c usbh_diskio.c user_diskio.c fdcan.c fmc.c freertos.c hash.c iwdg.c jpeg.c libjpeg.c jdata_conf.c lptim.c ltdc.c lwip.c ethernetif.c mbedtls.c net_sockets.c hardware_rng.c pdm2pcm.c quadspi.c rng.c sai.c sdmmc.c spi.c tim.c usart.c usb_host.c usbh_conf.c wwdg.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_TIM.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_eth.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_fdcan.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rng.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32h7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/LibJPEG
    ../Middlewares/Third_Party/LibJPEG/source/: jcapimin.c jcapistd.c jdapimin.c jdapistd.c jcomapi.c jcparam.c jctrans.c jdtrans.c jcinit.c jcmaster.c jcmainct.c jcprepct.c jccoefct.c jccolor.c jcsample.c jcdctmgr.c jfdctint.c jfdctfst.c jfdctflt.c jchuff.c jcarith.c jcmarker.c jdatadst.c jdmaster.c jdinput.c jdmainct.c jdcoefct.c jdpostct.c jdmarker.c jdhuff.c jdarith.c jddctmgr.c jidctint.c jidctfst.c jidctflt.c jdsample.c jdcolor.c jdmerge.c jquant1.c jquant2.c jdatasrc.c jaricom.c jerror.c jmemmgr.c jutils.c jmemnobs.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/mbedTLS
    ../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c pk_wrap.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509write_crt.c x509write_csr.c x509_create.c x509_crl.c x509_crt.c x509_csr.c xtea.c
  group Middlewares/PDMFilter
    ../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_IAR.a
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Src/: usbh_audio.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Src/: usbh_mtp.c usbh_mtp_ptp.c
  group Utilities
    ../Utilities/JPEG/: jpeg_utils.c
